options:
  parameters:
    generate_options: no_gui
    id: jammer
    output_language: python
    title: Jammer
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 2412e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: '50'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_noise_source_x_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
